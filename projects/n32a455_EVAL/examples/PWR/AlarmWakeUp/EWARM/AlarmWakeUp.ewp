# IAR project AlarmWakeUp.ewp, settings and files
configuration N32A455 (ARM, debug)
  General.OGChipSelectEditMenu: N32A455VE Nations N32A455VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32A455; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32a455_std_periph_driver/inc; ../../../../bsp/inc; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/CMSIS/core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AlarmWakeUp.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32A455\N32A455xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_adc.c n32a455_bkp.c n32a455_can.c n32a455_crc.c n32a455_dac.c n32a455_dbg.c n32a455_dma.c n32a455_exti.c n32a455_flash.c n32a455_gpio.c n32a455_i2c.c n32a455_iwdg.c n32a455_pwr.c n32a455_qspi.c n32a455_rcc.c n32a455_rtc.c n32a455_sdio.c n32a455_spi.c n32a455_tim.c n32a455_usart.c n32a455_wwdg.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455_EWARM.s
  group USER
    ../src/: main.c n32a455_it.c User_Delay_Config.c User_LED_Config.c User_RTC_Config.c
